Commit message: Activity6

File: src/my_robot_description/urdf/rubot/rubot_mecanum.urdf (robot description, URDF)
Before this commit: robot rubot, 9 links, 8 joints
Joints:
- joint scan_joint: axis 0 0 3.14 -> 0 0 1
